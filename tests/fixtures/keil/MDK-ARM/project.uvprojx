# Keil uVision project project.uvprojx, settings and files
target Debug (ARM-ADS)
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Core\Inc;..\Drivers\Inc
  group Application
    ../Core/Src/: main.c startup.s
  group Drivers
    ../Drivers/Src/: uart.c
target Release ()
  c define: USE_HAL_DRIVER NDEBUG
  c include: ..\Core\Inc
  group left out of the first target's files
    ../Core/Src/: startup.s
    ../Drivers/Src/: uart.c
